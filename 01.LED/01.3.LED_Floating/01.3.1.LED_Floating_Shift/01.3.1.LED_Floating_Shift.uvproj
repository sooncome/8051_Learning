# Keil uVision project 01.3.1.LED_Floating_Shift.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 01.3.1.LED_Floating_Shift +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
